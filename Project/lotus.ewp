# IAR project lotus.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\Users; ..\STM8S_StdPeriph_Driver\inc; ..\Users\driver; ..\Users\hardware; ..\Users\program; ..\Users\System
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: lotus.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group driver
    ../Users/driver/: iwdg.c iwdg.h
  group stm8s_driver/src
    ../STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim4.c stm8s_uart1.c
  group System
    ../Users/system/: config.h FIFOManage.c FIFOManage.h MSG.h mylib.c SystemInit.c
  group user
    ../Users/: main.c Mp3ModuleControl.c stm8s_conf.h stm8s_it.c stm8s_it.h timebase.c timebase.h uart.c uart.h WS2812B.c
